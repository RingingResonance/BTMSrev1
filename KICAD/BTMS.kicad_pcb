# Repository RingingResonance/BTMSrev1

File Readme.txt:

Battery Charge/Discharge and Heater Controller for small electric vehicles.

This system provides Battery telemetry services such as Voltage, Current, and Temperature. 

It also regulates charge/discharge voltages, limits current when battery temps are too high or too low, controls a battery heater for cold environments, and basic cooling fan control.
Works with lithium ion batteries, but does not provide cell ballancing. That must be done with a dedicated BMS.
The circuit provided should handle up to 30 amps with proper cooling. It also does basic error logging and will shut down the system on events such as under/over voltage, over current, temps out of range, internal CPU errors, etc. with room to expand.

At this time, Feb 19, 2022, Testing and verifying operation of circuit and firmware. System seems to be working as intended, but I'm still working on features and a few bugs here and there.

Heater circuit needs a higher current inductor to prevent smoke release.

Output side MOSFET drive circuit needs some fine tuning for effecientcy, but otherwise works and has been tested up to 1300 watts a few times on a 15min ride.

Charge circuit seems to work as intended, but all relays need bigger start capacitors, or better start circuits to succesfully latch.

Firmware needs display and monitoring routines written and reimplemented, and needs refactoring of several routines such as but not limited to the regulation routine for the purpose of saving code space, speed, and readability.

## KiCad design KICAD/BTMS.kicad_pcb

Parts:
C1, C3, C6, C10, C11, C12, C64, C99, C100: 1uf 25v; C_0603; Digi-Key_PN 1276-1102-1-ND
C2, C8, C13, C15, C16, C17, C18, C19, C20, C21, C22, C23, C36, C65, C75, C76, C110: 0.1uf film; C_0603; Digi-Key_PN PCF1126CT-ND
C4, C5, C14, C24, C25, C26, C27, C28, C29, C30, C31, C32, C33, C92, C93, C104, C109: 10uf 100v; C_1210; Digi-Key_PN 490-16266-1-ND
C7, C9, C37, C38, C39, C40, C42, C43, C44, C45, C46, C47, C48, C49, C50, C51, C52, C53, C54, C55, C56, C57, C58, C59, C60, C61, C62, C63, C94, C95, C96, C97, C98, C101, C103, C105, C106, C107, C108: 1uf 100v; C_0805; Digi-Key_PN 490-10918-1-ND
C34, C35, C41, C66, C69, C70, C71, C72, C73, C74, C77, C78, C79, C80, C81, C82, C83, C84, C85, C86, C87, C88, C89, C90, C91: 10uf 25v; C_0805; Digi-Key_PN 490-10748-1-ND
C67: 0.1uf film; C_0805; Digi-Key_PN 490-10918-1-ND
C68, C102: 0.1uf 100v; C_0603; Digi-Key_PN 311-1523-1-ND
C111, C112, C113, C114, C115: 100uf 16v; CP_Elec_6.3x5.7; Digi-Key_PN 1572-1239-1-ND
D1, D2, D3, D5, D7, D13, D14, D24, D25, D26, D32, D34, D36, D45, D49, D50, D51, D52: 15V; D_SOD-123; Digi-Key_PN DDZ15-7DICT-ND
D4, D9, D10, D28, D58: D_Schottky_AAK; TO-277A; Digi-Key_PN FSV20100VCT-ND
D6, D8, D11, D12, D15, D16, D27, D29, D31, D33, D35, D47, D48, D53, D54, D55, D56, D62: Diode40V; D_0603; Digi-Key_PN CCS15S40L3FCT-ND
D17: chgDetect; LED_0603; Digi-Key_PN VLMB1310-GS08CT-ND
D18: Error; LED_0603; Digi-Key_PN 732-4978-1-ND
D19: CPUact; LED_0603; Digi-Key_PN 1516-1055-1-ND
D20, D42, D43, D44, D57, D59, D60, D61: D_Schottky100V; D_SOD-123; Digi-Key_PN MBR0580-TPMSCT-ND
D21: Output; LED_0603; Digi-Key_PN 516-2486-1-ND
D22: Heat; LED_0603; Digi-Key_PN 516-2486-1-ND
D23: Charge; LED_0603; Digi-Key_PN 516-2486-1-ND
D30: Power; LED_0603; Digi-Key_PN 1516-1055-1-ND
D37: HeatEnable; LED_0603; Digi-Key_PN 516-2486-1-ND
D38: ChrgEnable; LED_0603; Digi-Key_PN 516-2486-1-ND
D39: AUXpwr; LED_0603; Digi-Key_PN 516-2486-1-ND
D40: Contactor; LED_0603; Digi-Key_PN 516-2486-1-ND
D41: Cool; LED_0603; Digi-Key_PN 516-2486-1-ND
D46: Q_SCR_KAG; TO-252-2; Digi-Key_PN 1740-1071-1-ND
F1: 2A; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
F2: Fuse1A; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
H1: Charge+; 1pin
H2: BatteryC-; 1pin
H3: BatteryP-; 1pin
H4: Battery+; 1pin
H5: Out+; 1pin
H6: Out-; 1pin
H7: Heater+; 1pin
H8: Heater-; 1pin
H9: Charge-; 1pin
H10, H12, H13, H16, H17: mnt; 1pin
H11, H18, H19: mnt; MountingHole_2.7mm
H14: AUX+; 1pin
H15: AUX-; 1pin
J1: fan; PinHeader_1x2_P2.54mm_Drill1.02mm; MPN 22-23-2021
J2: mContactor; PinHeader_1x2_P2.54mm_Drill1.02mm; MPN 22-23-2021
J3: Tac; PinHeader_1x2_P2.54mm_Drill1.02mm; MPN 22-23-2021
J5: ICSP; Pin_Header_Straight_1x05_Pitch2.54mm; MPN B5B-XH-A(LF)(SN)
J7, J17: 5Vout; PinHeader_1x2_P2.54mm_Drill1.02mm; MPN 22-23-2021
J9: key; PinHeader_1x2_P2.54mm_Drill1.02mm; MPN 22-23-2021
J10: U1COMMS; PinHeader_1x3_P2.54_Drill1.1mm; MPN 640456-3
J11: U2COMMS; PinHeader_1x3_P2.54_Drill1.1mm; MPN 640456-3
J13: IntBTemp; PinHeader_1x3_P2.54_Drill1.1mm; MPN 640456-3
J14: ctrlTemp; PinHeader_1x3_P2.54_Drill1.1mm; MPN 640456-3
J15: 12Vout; PinHeader_1x2_P2.54mm_Drill1.02mm; MPN 22-23-2021
J16: 12Vin; PinHeader_1x2_P2.54mm_Drill1.02mm; MPN 22-23-2021
L1, L2: 4.7uH; Inductor_Wurth_HCI-1890; Digi-Key_PN SRP1770TA-4R7MCT-ND
L3, L4, L5: 10uH; Inductor_Wurth_HCI-5040; Digi-Key_PN 732-5519-1-ND
Q1, Q2, Q3, Q8, Q10: PSMN5R6-100BS; TO-263-2; Digi-Key_PN 1727-7125-1-ND
Q4, Q5, Q6, Q7, Q11, Q12, Q17, Q18: DMN65D8L; SOT-23; Digi-Key_PN DMN65D8L-7DICT-ND
Q9, Q13: FDN340P; SOT-23; Digi-Key_PN FDN340PCT-ND
Q14, Q15, Q16: ZXTP2025FTA; SOT-23; Digi-Key_PN ZXTP2025FCT-ND
R1, R56, R57: 200K; R_0603; Digi-Key_PN P200KBYCT-ND
R2, R7, R54: 16K; R_0603; Digi-Key_PN 541-CRCW060316K0FKEAHPCT-ND
R3, R25: 12; R_0603; Digi-Key_PN 10-ERJ-UP3J120VCT-ND
R4, R6: 8; R_0603; Digi-Key_PN 541-8.06SCT-ND
R5: 6; R_0603; Digi-Key_PN 311-6.04HRCT-ND
R8, R13, R14, R18, R19, R20, R28, R31, R33, R41, R43, R53: 10K; R_0603; Digi-Key_PN RHM10KDCT-ND
R9, R32, R38, R51, R55: 3; R_0603; Digi-Key_PN 511-1769-1-ND
R10, R12, R15, R16, R17, R21, R26, R39, R40, R42, R45, R59, R60, R61, R62, R63, R64, R65, R66, R67, R68: 500; R_0603; Digi-Key_PN RNCP0603FTD499RCT-ND
R11, R22, R23, R24, R29, R30, R34, R35, R36, R37, R44, R46, R47, R48, R49, R50, R52: 1K; R_0603; Digi-Key_PN A130416CT-ND
U1: R-78HB12-0.5; TO-220-3_Horizontal; Digi-Key_PN 945-2445-ND
U2: ACS780xLRTR-050B; Allegro_PSOF-7_4.8x6.4mm_P1.60mm; Digi-Key_PN 620-1817-1-ND
U3: UCC27201DDAR; TI_SO-PowerPAD-8_ThermalVias; Digi-Key_PN 296-31998-1-ND
U4: FAN3111ESX; SOT-753; MPN FAN3111ESX; Digi-Key_PN FAN3111ESXCT-ND
U5: HCPL-3120; DIP-8_SMD; Digi-Key_PN 516-1789-1-ND
U6: L7805CV; TO-263-2; MPN L7805CV; Digi-Key_PN MC7805CD2TR4GOSCT-ND
U7: LTV-817S; SO-4_7.6x3.6mm_Pitch2.54mm; Digi-Key_PN 160-1367-5-ND
U8: dsPIC30F3011-PT; TQFP-44_10x10mm; Digi-Key_PN DSPIC30F301130IPT-ND
U9: LM62CIM3/NOPB; SOT-23; Digi-Key_PN LM62CIM3/NOPBCT-ND
U10, U11, U12, U13, U14: A41AS12VDC; A4series; Digi-Key_PN 2449-A41AS12VDC-ND
U15: NL17SZ74USG; SOT-23-8_Handsoldering; Digi-Key_PN NL17SZ74USGOSCT-ND

Connections:
+5C: C8.1, C15.1, C16.1, C17.1, C18.1, C22.1, C67.1, C77.1, C78.1, C79.1, C80.1, C81.1, C82.1, C83.1, C110.1, D15.1 (K), J5.2, J13.1, J14.1, Q9.3 (D), Q13.3 (D), R14.1, R28.1, R31.1, R44.1, R57.2, R61.2, U2.1 (VCC), U4.4 (XREF), U8.7 (VDD0), U8.17 (AVDD), U8.28 (VDD1), U8.40 (VDD2), U9.1 (G), U15.8 (VCC)
+5V: C64.1, C65.1, C66.1, C69.1, C70.1, C71.1, C72.1, J7.1, J17.1, Q9.2 (S), Q13.2 (S), R43.2, U6.3 (OUT), U7.4
+12V: C2.1, C13.1, C34.1, C35.1, C36.1, C73.1, C84.1, C85.1, C86.1, C87.1, C99.1, C100.1, D6.1 (K), D8.1 (K), D11.1 (K), D12.1 (K), D16.1 (K), D20.2 (A), D29.1 (K), D33.1 (K), D45.1 (K), D46.2 (A), D50.1 (K), D51.1 (K), D55.1 (K), D56.1 (K), D57.2 (A), J15.1, L4.2, R20.1, R32.2, U3.1 (VDD), U4.1 (VDD), U10.6 (Coil2), U11.6 (Coil2), U12.6 (Coil2), U13.6 (Coil2), U14.6 (Coil2)
/AUXpower: R42.1, R48.1, U8.27 (AN8/RB8)
/B+: C27.1, C32.1, C44.1, C51.1, C58.1, C94.1, C103.1, H4.1, R1.2, U2.6 (IP-)
/BC-: C24.2, C29.2, C40.2, C48.2, C56.2, C62.2, C98.2, H2.1, L2.1
/BCsense: C12.1, R11.1, U8.20 (EMUC3/AN1/VREF-/CN3/RB1)
/BVsense: C19.1, D15.2 (A), D62.1 (K), U8.19 (EMUD3/AN0/VREF+/CN2/RB0); also elsewhere on the board
/Btemp: C20.1, R29.1, U8.21 (AN2/~SS1~/CN4/RB2)
/CH+: C33.1, C43.1, C50.1, C52.1, D4.1 (A), D4.2 (A), D28.1 (A), D28.2 (A), H1.1, R7.1, R8.1, R53.1, R54.1
/CH-: C3.2, C6.2, C33.2, C43.2, C50.2, C52.2, C104.2, C105.2, C106.2, C107.2, D1.2 (A), D5.2 (A), D26.2 (A), D49.2 (A), H9.1, Q1.3 (S), U5.5 (VEE), U7.2
/CHctrl: R12.1, R37.1, U8.10 (PWM2H/RE3)
/CHdetect: D54.2 (A), R13.1, U7.3, U8.36 (~FLTA~/INT0/RE8)
/ChargeIn: C24.1, C29.1, C40.1, C48.1, C56.1, C62.1, C98.1, C104.1, C105.1, C106.1, C107.1, D4.3 (K), D10.3 (K), D28.3 (K), U11.7 (Common)
/CoolCTRL: R17.1, R50.1, U8.5 (RF0)
/Hctrl: R10.1, R36.1, U8.14 (PWM1H/RE1)
/HeatRLY: R15.1, R46.1, U8.31 (OSC2/CLKO/RC15)
/Heater+: F1.2, H7.1
/Heater-: C108.2, C109.2, H8.1, L5.2
/IntBus: C14.1, C25.1, C28.1, C30.1, C37.1, C38.1, C39.1, C45.1, C46.1, C47.1, C53.1, C54.1, C55.1, C59.1, C60.1, C61.1, C92.1, C93.1, C95.1, C96.1, C97.1, F2.2, Q8.2 (D), Q10.2 (D), U2.5 (IP+), U10.5 (NO1), U11.5 (NO1), U12.5 (NO1)
/KeepAlive: D53.2 (A), U8.41 (OC3/RD2)
/M+: C26.1, C31.1, C42.1, C49.1, C57.1, C63.1, C101.1, H5.1, L1.2
/MCLR: D35.1 (K), J5.1, U8.18 (~MCLR~)
/Mctrl+: R35.1, R59.1, R63.2, R68.1, U8.8 (PWM3H/RE5)
/Mctrl-: R60.1, U8.9 (PWM3L/RE4)
/PGMC: J5.5, U8.1 (PGC/EMUC/U1RX/SDI1/SDA/RF2)
/PGMD: J5.4, U8.44 (PGD/EMUD/U1TX/SDO1/SCL/RF3)
/TACinput: C75.1, D27.2 (A), R31.2, U8.42 (EMUC2/OC1/IC1/INT1/RD0)
/U1RX: R21.1, U8.35 (EMUC1/SOSCO/T1CK/U1ARX/CN0/RC14)
/U1TX: R26.1, U8.32 (EMUD1/SOSCI/T2CK/U1ATX/CN1/RC13)
/U2RX: R39.1, U8.3 (U2RX/CN17/RF4)
/U2TX: R40.1, U8.2 (U2TX/CN18/RF5)
/__PwrKey: D47.2 (A), R28.2, U8.4 (RF1)
/brdTemp: C23.1, R34.1, U8.26 (AN7/RB7)
/cTemp: C21.1, R30.1, U8.22 (AN3/INDX/CN5/RB3)
/chargeRLY: R16.1, R47.1, U8.43 (SCK1/RF6)
/mainContactor: R45.1, R49.1, U8.37 (EMUD2/OC2/IC2/INT2/RD1)
GND: C2.2, C4.2, C5.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C25.2, C26.2, C27.2, C28.2, C30.2, C31.2, C32.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C41.2, C42.2, C44.2, C45.2, C46.2, C47.2, C49.2, C51.2, C53.2, C54.2, C55.2, C57.2, C58.2, C59.2, C60.2, C61.2, C63.2, C64.2, C65.2, C66.2, C67.2, C68.2, C69.2, C70.2, C71.2, C72.2, C73.2, C74.2, C75.2, C76.2, C77.2, C78.2, C79.2, C80.2, C81.2, C82.2, C83.2, C84.2, C85.2, C86.2, C87.2, C88.2, C89.2, C90.2, C91.2, C92.2, C93.2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
unnamed: C1.1, D20.1 (K), D25.1 (K), D57.1 (K), U3.2 (HB)
unnamed: C1.2, D9.3 (K), D24.2 (A), D25.2 (A), D32.2 (A), L1.1, Q2.2 (D), Q8.3 (S), Q10.3 (S), Q14.3 (C), Q15.3 (C), R56.1, U3.4 (HS)
unnamed: C3.1, C6.1, D5.1 (K), D26.1 (K), D49.1 (K), R8.2, R53.2, U5.8 (VCC)
unnamed: C4.1, C5.1, C7.1, C9.1, L3.1, R9.1, U1.1 (VI)
unnamed: C10.1, C102.1, D33.2 (A), D55.2 (A), U1.3 (VO)
unnamed: C11.1, C41.1, C68.1, C74.1, C88.1, C89.1, C90.1, C91.1, D52.1 (K), L4.1, R32.1, R33.1, U6.1 (IN)
unnamed: C76.1, D45.2 (A), D46.3 (G), R52.2
unnamed: C108.1, C109.1, D58.3 (K), F1.1, U10.7 (Common)
unnamed: C111.1, D6.2 (A), R62.2, U10.1 (Coil1)
unnamed: C111.2, Q5.3 (D), R62.1
unnamed: C112.1, D8.2 (A), R64.2, U11.1 (Coil1)
unnamed: C112.2, Q6.3 (D), R64.1
unnamed: C113.1, D11.2 (A), R65.2, U12.1 (Coil1)
unnamed: C113.2, Q4.3 (D), R65.1
unnamed: C114.1, D12.2 (A), R66.2, U13.1 (Coil1)
unnamed: C114.2, Q11.3 (D), R66.1
unnamed: C115.1, D16.2 (A), R67.2, U14.1 (Coil1)
unnamed: C115.2, Q12.3 (D), R67.1
unnamed: D1.1 (K), Q1.1 (G), R6.2
unnamed: D2.1 (K), Q2.1 (G), R5.2, R55.1
unnamed: D3.1 (K), Q3.1 (G), R4.2
unnamed: D7.1 (K), Q12.1 (G), R17.2
unnamed: D10.1 (A), D10.2 (A), L2.2, Q1.2 (D)
unnamed: D13.1 (K), Q5.1 (G), R15.2
unnamed: D14.1 (K), Q6.1 (G), R16.2
unnamed: D17.2 (A), R22.2
unnamed: D18.2 (A), R23.2
unnamed: D19.2 (A), R24.2
unnamed: D21.2 (A), R35.2
unnamed: D22.2 (A), R36.2
unnamed: D23.2 (A), R37.2
unnamed: D24.1 (K), Q8.1 (G), R3.2, R51.1
unnamed: D27.1 (K), J3.2
unnamed: D29.2 (A), D56.2 (A), J16.1
unnamed: D30.2 (A), R44.2
unnamed: D31.1 (K), J9.1
unnamed: D31.2 (A), D47.1 (K), D48.1 (K)
unnamed: D32.1 (K), Q10.1 (G), R25.2, R38.1
unnamed: D34.1 (K), Q4.1 (G), R42.2
unnamed: D35.2 (A), R14.2
unnamed: D36.1 (K), Q11.1 (G), R45.2
unnamed: D37.2 (A), R46.2
unnamed: D38.2 (A), R47.2
unnamed: D39.2 (A), R48.2
unnamed: D40.2 (A), R49.2
unnamed: D41.2 (A), R50.2
unnamed: D42.1 (K), R25.1
unnamed: D42.2 (A), D43.2 (A), Q14.1 (B), Q15.1 (B), U3.3 (HO)
unnamed: D43.1 (K), R3.1
unnamed: D44.1 (K), R5.1
unnamed: D44.2 (A), Q16.1 (B), U3.8 (LO)
unnamed: D48.2 (A), Q7.3 (D), Q9.1 (G), Q13.1 (G), R43.1
unnamed: D53.1 (K), D54.1 (K), Q7.1 (G), R41.2
unnamed: D58.1 (A), D58.2 (A), L5.1, Q3.2 (D)
unnamed: D59.1 (K), R56.2
unnamed: D59.2 (A), D61.1 (K), R57.1, U15.7 (_PR)
unnamed: D60.1 (K), U15.3 (_Q)
unnamed: D60.2 (A), Q17.3 (D), R60.2, U3.6 (LI)
unnamed: F2.1, L3.2, R9.2
unnamed: H14.1, U12.7 (Common)
unnamed: J1.1, U14.5 (NO1)
unnamed: J1.2, U14.7 (Common)
unnamed: J2.1, U13.5 (NO1)
unnamed: J2.2, U13.7 (Common)
unnamed: J10.1, R39.2
unnamed: J10.3, R40.2
unnamed: J11.1, R21.2
unnamed: J11.3, R26.2
unnamed: J13.3, R29.2
unnamed: J14.3, R30.2
unnamed: Q14.2 (E), R51.2
unnamed: Q15.2 (E), R38.2
unnamed: Q16.2 (E), R55.2
unnamed: Q17.1 (G), R68.2
unnamed: Q18.1 (G), R63.1
unnamed: Q18.3 (D), R61.1, U15.6 (_CLR)
unnamed 117: R1.1, R2.2; also elsewhere on the board
unnamed: R4.1, U4.5 (OUT)
unnamed: R6.1, U5.6 (VO), U5.7 (VO)
unnamed: R10.2, U4.3 (IN+)
unnamed: R11.2, U2.3 (VOUT)
unnamed: R12.2, U5.2 (A)
unnamed: R18.2, U8.15 (PWM1L/RE0)
unnamed: R19.2, U8.11 (PWM2L/RE2)
unnamed: R22.1, U8.23 (AN4/QEA/IC7/CN6/RB4)
unnamed: R23.1, U8.24 (AN5/QEB/IC8/CN7/RB5)
unnamed: R24.1, U8.25 (AN6/OCFA/RB6)
unnamed: R34.2, U9.2 (D)
unnamed: R7.2, R54.2, U7.1
unnamed: R59.2, U3.5 (HI)

Board: 4 copper layers, 126.2 x 137.4 mm, 315 parts (29 on the bottom side), 128 nets.

Other parts of the board:
R27: 1K; R_0603

Their connections:
/BVsense: R27.2; also elsewhere on the board
unnamed 117: R27.1; also elsewhere on the board

## Code that names these connections

File firmware/EVBatteryCTRLv1.X/IRQs.c (part):

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
/* Charge Detect IRQ. */
void __attribute__((interrupt, no_auto_psv)) _INT0Interrupt (void){
    PORTBbits.RB6 = 1;
    //reset peak power when we plug in a charger.
    peak_power = 0;
    //Check for partial charge status to see if we need to do a full charge to ballance the cells.
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
/* Wheel Rotate and low priority IRQ. */
void __attribute__((interrupt, no_auto_psv)) _INT1Interrupt (void){
    PORTBbits.RB6 = 1;
    wheelTime = TMR3;
    TMR3 = 0;
    if (wheelSpin)
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}
/* Wheel Rotate Timer 3 IRQ */
void __attribute__((interrupt, no_auto_psv)) _T3Interrupt (void){
    PORTBbits.RB6 = 1;
    speed = 0;
    wheelSpin = 0;
    //End IRQ
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
/* Non-critical systems. Timer 4 IRQ */
void __attribute__((interrupt, no_auto_psv)) _T4Interrupt (void){
    PORTBbits.RB6 = 1;
    //Check settings ram in background. (lowest priority IRQ))
    if(check_ramSets()){
        //If failed, shutdown and attempt to recover.
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
/* Analog Input IRQ */
void __attribute__((interrupt, no_auto_psv)) _ADCInterrupt (void){
    PORTBbits.RB6 = 1;
    
//BUFFER 0 is Battery Voltage
//BUFFER 1 is Battery Current
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
/* Data and Command input and processing IRQ for Port 1 */
void __attribute__((interrupt, no_auto_psv)) _U1RXInterrupt (void){
    PORTBbits.RB6 = 1;
    Command_Interp(PORT1);
/****************************************/
    /* End the IRQ. */
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
/* Data and Command input and processing IRQ for Port 2. */
void __attribute__((interrupt, no_auto_psv)) _U2RXInterrupt (void){
    PORTBbits.RB6 = 1;
    Command_Interp(PORT2);
/****************************************/
    /* End the IRQ. */
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
/* Output IRQ for Port 1 */
void __attribute__((interrupt, no_auto_psv)) _U1TXInterrupt (void){
    PORTBbits.RB6 = 1;
    //Dispatch the buffer to the little 4 word Serial Port buffer as it empties.
    while(U1STAbits.UTXBF == 0 && (Buff_index[PORT1] < Buff_count[PORT1])){
        U1TXREG = Buffer[PORT1][Buff_index[PORT1]];
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
/* Output IRQ for Port 2 */
void __attribute__((interrupt, no_auto_psv)) _U2TXInterrupt (void){
    PORTBbits.RB6 = 1;
    //Dispatch the buffer to the little 4 word Serial Port buffer as it empties.
    while(U2STAbits.UTXBF == 0 && (Buff_index[PORT2] < Buff_count[PORT2])){
        U2TXREG = Buffer[PORT2][Buff_index[PORT2]];
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
/* Heartbeat IRQ, Once every Second. Lots of stuff goes on here. */
void __attribute__((interrupt, no_auto_psv)) _T1Interrupt (void){
    PORTBbits.RB6 = 1;
    ADCON1bits.ADON = 1;    // turn ADC on to get a sample.
    
    /* Power off TIMER stuff. Do this to save power.
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    if(main_power){
        PowerOffTimer = sets.PowerOffAfter;      //reset the timer when main_power is on.
        PowerOffTimerSec = 59;              //60 seconds.
        PORTDbits.RD2 = 1; //Enable Keep Alive signal. System keeps itself on while main_power is enabled.
    }
    else{
        //When main_power is off count down in minutes.
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    }
    // Check for charger disconnect.
    if(PORTEbits.RE8 == 0){
        PORTBbits.RB4 = 0;          //charger light off.
        charge_power = 0;
        chrg_check = 0;
    }

    //Fan control
    if(main_power && (battery_temp > sets.batt_fan_start || my_temp > sets.ctrlr_fan_start || motor_ctrl_temp > sets.ctrlr_fan_start)){
        PORTFbits.RF0 = 1;
    }
    else if(main_power == 0 || (battery_temp < (sets.batt_fan_start - 5) && my_temp < (sets.ctrlr_fan_start - 5) && motor_ctrl_temp < (sets.ctrlr_fan_start - 5))){
        PORTFbits.RF0 = 0;
    }
    
    //Main power check
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    if(pwr_detect){
        if(error_blink == 1){
            error_blink = 0;
            PORTBbits.RB5 = 0;
        }
        else{
            error_blink = 1;    //Used for blinking stuff on displays.
            if(vars.fault_count != 0){
                PORTBbits.RB5 = 1;
            }
        }
    }
    else{
        PORTBbits.RB5 = 0;
    }
    
    
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/* 0.125 second IRQ */
//Used for some critical math timing operations. Cycles through every 1/8 sec.
void __attribute__((interrupt, no_auto_psv)) _T2Interrupt (void){
    PORTBbits.RB6 = 1;
    float power = 0;
    
    //Relay On Timers. Wait a little bit after turning on the relays before trying to regulate.
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
/* CPU TRAPS, log erros here and shut down if needed.*/
void __attribute__((interrupt, no_auto_psv)) _FLTAInterrupt (void){
    PORTBbits.RB6 = 1;
    io_off();
    fault_shutdown = 1;
    fault_log(0x0C);        //PWM fault. External.
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            fault_log(0x12);
        }
    }
    PORTBbits.RB6 = 1;
    io_off();
    fault_shutdown = 1;
    if(osc_fail_event == 0){
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    INTCON1bits.OSCFAIL = 0;
}
void __attribute__((interrupt, no_auto_psv)) _AddressError (void){
    PORTBbits.RB6 = 1;
    io_off();
    fault_shutdown = 1;
    //send_string(0x03, "Address Error Event.");
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    INTCON1bits.ADDRERR = 0;
}
void __attribute__((interrupt, no_auto_psv)) _StackError (void){
    PORTBbits.RB6 = 1;
    io_off();
    fault_shutdown = 1;
    //send_string(0x03, "Stack Error Event.");
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    INTCON1bits.STKERR = 0;
}
void __attribute__((interrupt, no_auto_psv)) _MathError (void){
    PORTBbits.RB6 = 1;
    io_off();
    fault_shutdown = 1;
    //send_string(0x03, "Math Error Event.");
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    INTCON1bits.MATHERR = 0;
}
void __attribute__((interrupt, no_auto_psv)) _ReservedTrap7 (void){
    PORTBbits.RB6 = 1;
    io_off();
    fault_shutdown = 1;
    fault_log(0x11);
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
## Commit log

2021-06-18 Initial Commit and Upload of BTMS Rev. 1
2021-06-18 Added Firmware.
2021-06-18 Reorganized files.
2021-06-18 Deleted outdated board renderings.
2021-06-18 Updated KICAD custom parts.
2021-06-18 Updated fault code and command set files.
2021-06-18 Created PDF schematic and updated Silkscreen on board layout.
2021-06-18 Added readme
2021-06-18 Updated board layout to reflect schematic.
2021-07-03 Updated silk screen placement for some parts.
2021-08-07 Updated parts list. Updated Gerber files. Updated board to reflect schematic. Tweaked some parts of the schematic.
2021-08-08 Updated U3 to reflect proper pinout for UCC27201DDAR
2021-08-08 Updated PDF to reflect schematic changes.
2021-12-17 Cleaned up some corners on PCB layout. I don't like the main buck converter half bridge design. Might change later. Still Need To Test This Revision.
2021-12-24 Cleaned up a few things. Added mosfet to help protect against both high and low side fets from being on at the same time. Generated Gerber Files. Getting ready to fabricate this board and begin testi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
2022-01-02 Updated firmware for schematic changes. Getting ready to test new design for the first time.
2022-01-02 Refactored and optimized fault code readout routine. <-Need to test this once boards are assembled and functioning.
2022-01-03 Refactored Command Handler for serial port 1. Need to test functionality before continuing to refactor further
2022-01-03 Added Digikey parts list. Ordered parts, but many critical parts are on backorder so I will be reusing parts from the older prototypes that didn't explode.
2022-02-13 Began board design bug fixes and upgrades. Began implementing vehicle speed calculation routines. Fixed a bug where system would power itself off 1 sec after unplugging charger. Fixed a bug where hea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
2022-02-14 Removed R58 from circuit design; not needed. Changed firmware to use built in dead time generator and verified that the High and Low differential pair is configured correctly. Circuit seems to work a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
2022-02-14 Added some pictures of the test board.
2022-02-14 Updated README.txt
2022-02-14 Updated battery voltage divider.
2022-02-14 Fixed a mislabeled net; changed from 5vP to 5vC on U4. Need to update board layout; changed some capacitors and other previously noted schematic changes.
2022-02-15 Refactored some comments and code. Checked and changed IRQ priority settings to ensure the analog IRQ is always highest priority.
2022-02-15 Refactoring and cleaning up DATA IO routines. Making sure it's all scalable and allows the CPU to multi-task better than before.
2022-02-16 Refactored Command Interpreter code and Serial port code to allow multi-tasking. FIXME: serial console is buggy but mostly functional for some reason. Too tired to fix it right now.
2022-02-16 Fixed buggy serial port stuttering and garbage data.
2022-02-18 Fixed EEPROM storage so that it works now. Added system for checking Program memory checksum and EEPROM checksum.
2022-02-19 Refactored EEPROM and Checksum code. Added Settings ram checksum checking feature and added a systems debug mode that shuts down all services except the two serial ports.
2022-02-20 Updated readme to list current state of project.
2022-02-25 Major refactoring, and optimizations. Added some groundwork for custom serial port displays. NEW BUGS: Serial ports hang for some unknown reason. Heatcal gets ran multiple times when charger is plugg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
2022-02-26 Refactored charge detect and regulation routines.
    Fixed some bugs with the heat control and calibration. Heat cal only runs once when starting from cold and dead, but no implementation for running heat cal on warm start charger plugin. <- TODO
    Serial port still hangs sometimes.
2022-02-26 Added routines in the heart beat IRQ to check for serial port buffer overflow, log an error code, and clear the buffer if detected. Also changed
    checksum timer IRQ priority to 1 as I think that is what was causing the receive IRQ to hang during high CPU loads. Will test tomorrow.
2022-02-27 A little bit of refactoring. A few minor bug fixes and adjustments of code. System now adjusts current linearly from battery temperature limits rather than hard coded arbitrary % current set points. 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
2022-03-12 Fixed bug where charge current detect timeout wouldn't time out.
2022-06-12 Updated prototype HUD routines to work and be configurable. Need to implement system config upload/download routines. Fixed bug where not all settings or variables would be correctly saved to or retr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
2022-06-13 Updated Commands list. Fixed a bug with HUD custom data not working. Heater cal bug where heater cal runs after reset even though it's set to disabled has reappeared. Added Version String command.
2022-06-13 Moved HUD display to Timer 5 with a low priority IRQ.
2022-06-13 Updated timer 5 IRQ priority. Changed default HUD config to work with display that I have.
2022-06-14 Minor optimizations.
2022-06-15 Refactored some code. Fixed serial ports interfering with each other.
2022-06-15 Refactored analog input routines. Fixed bug where open circuit voltage routines would not get the correct voltages.
2022-06-16 Started work on settings/memory upload + download system.
2022-09-14 Fixed bug where a shutdown and insufficient current error would be logged even when the charger was working.
2024-01-30 Changed licensing of firmware from GNU to MIT.

Notices in the files:
firmware/EVBatteryCTRLv1.X/IRQs.c:
Copyright (C) <2020>  <Jarrett R. Cigainero>
This program is free software: you can redistribute it and/or modify
it under the terms of the GNU General Public License as published by
the Free Software Foundation, either version 3 of the License, or
(at your option) any later version.
